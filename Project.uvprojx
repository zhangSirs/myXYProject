# Keil uVision project Project.uvprojx, settings and files
target project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DcTwo_434 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Micrium\Software\uC-CPU;..\Micrium\Software\uC-CPU\ARM-Cortex-M3\IAR;..\Micrium\Software\uC-LIB;..\Micrium\Software\uCOS-III;..\Micrium\Software\uCOS-III\Source;..\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR;..\Micrium\Software\uCOS-III\Cfg\Template;..\Micrium\Software\uC-CPU\Cfg\Template;..\Micrium\Software\uC-LIB\Cfg\Template;..\USER;..\Meter;..\Display;..\Mt628;..\BSP;..\Insu;..\ChgCtrl;..\enc28j60;..\xinya_proto;..\LWIP;..\LWIP\lwip-1.3.2\src\api;..\LWIP\lwip-1.3.2\src\core\ipv4;..\LWIP\lwip-1.3.2\src\core\ipv6;..\LWIP\lwip-1.3.2\src\core\snmp;..\LWIP\lwip-1.3.2\src\include;..\LWIP\lwip-1.3.2\src\include\ipv4;..\LWIP\lwip-1.3.2\src\include\ipv4\lwip;..\LWIP\lwip-1.3.2\src\include\lwip;..\LWIP\lwip-1.3.2\src\include\netif;..\LWIP\lwip-1.3.2\src\netif;..\LWIP\lwip-1.3.2\src\netif\ppp;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\src;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\startup\arm;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../USER/: stm32f2xx_conf.h include.h config.h GlobalVariable.h GlobalVariable.c main.c stm32f2xx_it.c ChgCtrlA.c ChgCtrlB.c DisplayA.c DisplayB.c dwin.c HvdcCan.c mcp2515.c spi3.c mt628.c rf4g.c NetOptA.c NetOptB.c NetOpt.c Record.c Hvdc.c EeromIIC2.c FlashOnChip.c ScanAdc.c ADS1015.c AdcIIC1.c insu_dete.c meter.c bms.c bms_timer.c usart.c bms_can.c RealTime.c pwm.c
  group BSP
    ../BSP/: bsp.c bsp_init.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f207xx.s
  group FW-LIB
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group uC-CPU
    ../Micrium/Software/uC-CPU/: cpu_core.c
    ../Micrium/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu_c.c cpu_a.asm
  group uC-LIB
    ../Micrium/Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../Micrium/Software/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uCos-III
    ../Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
    ../Micrium/Software/uCOS-III/Cfg/Template/: os_app_hooks.c
  group uCos-CFG
    ../Micrium/Software/uCOS-III/Cfg/Template/: os_cfg.h os_cfg_app.h
    ../Micrium/Software/uC-CPU/Cfg/Template/: cpu_cfg.h
    ../Micrium/Software/uC-LIB/Cfg/Template/: lib_cfg.h
  group xinya_proto
    ../xinya_proto/: netconfig.c xinya_proto.c
  group enc28j60
    ../enc28j60/: ENC28J60.C SPI.C
  group lwip-api
    ../LWIP/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core
    ../LWIP/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip-core-ipv4
    ../LWIP/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-core-snmp
    ../LWIP/lwip-1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group lwip-netif
    ../LWIP/lwip-1.3.2/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
